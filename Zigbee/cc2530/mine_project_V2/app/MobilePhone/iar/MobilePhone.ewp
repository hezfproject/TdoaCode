# IAR project MobilePhone.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: xSMS_TEMPLATE; MENU_CLOCKFORMAT; CELLSWITCH_DEBUG; MP_INFORMATION; HOLD_AUTO_START; SMS_SENDBOX; NEW_MENU_LIB; WATCHDOG=TRUE; NEW_DOUBLE_NVID_OP; AUDIO_SERIAL; NWK_AUTO_POLL; OSC32K_CRYSTAL_INSTALLED=FALSE; xAUDIO_TEST; xSINGLE_AUDIO_TEST; xMULTIAUDIO_TEST; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_AUDIO=TRUE; HAL_SPI=FALSE; HAL_UART=FALSE; HAL_LED=FALSE; HAL_AES=FALSE; HAL_KEY=TRUE; IDX_THRESHOLD=12; xMACNODEBUG; xMAC_NO_PARAM_CHECK; HAL_AUDIO=TRUE; HAL_DMA=TRUE; HAL_AES=FALSE; MAC_CFG_TX_DATA_MAX=8; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=8
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\; ..\src\MenuLib; ..\src\MenuLib\util; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\MCU\CC2530; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MT; ..\..\..\..\..\..\common; ..\..\..\..\..\common\lcd; ..\..\..\..\..\..\common\2g; ..\..\..\..\..\..; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\MobilePhone; ..\..\..\driver\MobilePhone\audio; ..\..\..\driver\MobilePhone\common; ..\..\..\driver\MobilePhone\key; ..\..\..\driver\MobilePhone\lcd; ..\..\..\driver\MobilePhone\ioexpand
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\cfg\ti_51ew_cc2530b.xcl
configuration Release_StationCheck (8051)
  as the first configuration, except:
  ICC8051.CCDefines: xSMS_TEMPLATE; CFG_STATION_CHECK; CFG_STATION_SIMULATE; CFG_TEST_WIRELESS; HALNODEBUG; MACNODEBUG; MENU_CLOCKFORMAT; CELLSWITCH_DEBUG; MP_INFORMATION; HOLD_AUTO_START; xSMS_SENDBOX; NEW_MENU_LIB; WATCHDOG=TRUE; NEW_DOUBLE_NVID_OP; AUDIO_SERIAL; NWK_AUTO_POLL; OSC32K_CRYSTAL_INSTALLED=FALSE; xAUDIO_TEST; xSINGLE_AUDIO_TEST; xMULTIAUDIO_TEST; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_AUDIO=TRUE; HAL_SPI=FALSE; HAL_UART=FALSE; HAL_LED=FALSE; HAL_AES=FALSE; HAL_KEY=TRUE; IDX_THRESHOLD=12; xMACNODEBUG; xMAC_NO_PARAM_CHECK; HAL_AUDIO=TRUE; HAL_DMA=TRUE; HAL_AES=FALSE; MAC_CFG_TX_DATA_MAX=8; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=8
  ICC8051.CCOptStrategy: 1
  group Application
    ../src/: MobilePhone.c MobilePhone.h MobilePhone_cfg.h MobilePhone_Dep.c MobilePhone_Dep.h MobilePhone_Function.c MobilePhone_Function.h MobilePhone_global.c MobilePhone_global.h MobilePhone_Main.c MobilePhone_MenuLib.c MobilePhone_MenuLib.h MobilePhone_MenuLibChinese.h MobilePhone_Osal.c
  group Application/Menu
    ../src/MenuLib/Util/: 51PY.c 51PY.h MenuAdjustUtil.c MenuAdjustUtil.h MenuChineseInputUtil.c MenuChineseInputUtil.h TimeUtil.c TimeUtil.h TimeUtilChinese.h
    ../src/MenuLib/: MenuLib_global.c Menulib_global.h MenuLib_Nv.c MenuLib_Nv.h MenuLib_orphan.c MenuLib_orphan.h MenuLib_tree.c MenuLib_tree.h
  group HAL/Common
    ../../../../../common/lcd/: Lcd_aging_check.c Lcd_aging_check.h
  group HAL/Drivers
    ../../../driver/include/: hal_adc.h hal_flash.h hal_key.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530MP/Config
    ../../../driver/MobilePhone/: hal_board_cfg.h
  group HAL/Target/CC2530MP/Drivers
    ../../../driver/MobilePhone/audio/: audio_ambe_serial.c codec_fm11ge300.c codec_uart.c voicedqueue.c
    ../../../driver/MobilePhone/: hal_adc.c hal_alarm.c hal_audio.c hal_dma.c hal_flash.c hal_flash.s51 hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c KeyAudioISR.c
    ../../../driver/MobilePhone/common/: hal_assert.c hal_assert.h hal_drivers.c hal_drivers.h OnBoard.c OnBoard.h
    ../../../driver/MobilePhone/ioexpand/: i2c.c ioexpand.c
    ../../../driver/MobilePhone/key/: key.c
    ../../../driver/MobilePhone/lcd/: lcd_serial.c
  group HAL/Target/CC2530MP/Includes
    ../../../driver/MobilePhone/: hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/high_level/: mac_cfg.c mac_pib.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../third_party/TIMAC-CC2530-1.3.1/Projects/mac/libraries/cc2530/IAR/bin/Lib/: macLib_cc2530-Banked.lib macLib_cc2530.lib
  group MAC/Include
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h mac_tx.h
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h
  group OSAL
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/osal/mcu/cc2530/: OSAL_Nv.c
    ../cfg/: ti_51ew_cc2530b.xcl
  group Services
    ../../../../../../common/2g/: numtrans.c numtrans.h
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/services/saddr/: saddr.c saddr.h
  group Util
    ../../../util/: delay.s51 SleepUtil.c StringUtil.c WatchDogUtil.c
