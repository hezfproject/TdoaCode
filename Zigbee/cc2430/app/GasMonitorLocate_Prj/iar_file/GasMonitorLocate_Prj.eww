<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GasMonitorLocate_Prj.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>wxlEndDevice</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>wxlRouter</configuration>
      </member>
      <member>
        <project>GasMonitorLocate_Prj</project>
        <configuration>wxlCoordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


