# IAR project LocSys.ewp, settings and files
configuration Station (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: STATION_PROJECT; ASSERT_RESET; POOLSIZE=5; TX_NEXT_CHECK; LOCSYS_NODEROLE_STATION; xSLEEPTIME_ACCOUNTING; xPOWER_SAVING; MAC_CFG_TX_DATA_MAX=6; MAC_CFG_TX_MAX=10; MAC_CFG_RX_MAX=10; HAL_UART=FALSE; HAL_DMA=TRUE; HAL_AES=FALSE; HAL_FLASH=FALSE; xNON_BANKED; xLOCSYS_NO_SPI_CMD; WATCHDOG=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\MCU\CC2530; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MT; ..\..\..\..\..\..\common; ..\..\..\..\..\..\common\1g; ..\..\..\..\..\..; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\LocSys\Station; ..\..\..\driver\LocSys\Station\common; ..\..\..\driver\MobilePhone\lcd; ..\..\..\driver\MobilePhone\ioexpand
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\cfg\ti_51ew_cc2530b.xcl
configuration Card (8051)
  as the first configuration, except:
  ICC8051.CCDefines: xOSC32K_CRYSTAL_INSTALLED=FALSE; LOCSYS_NODEROLE_CARD; xSLEEPTIME_ACCOUNTING; POWER_SAVING; MAC_CFG_TX_DATA_MAX=6; MAC_CFG_TX_MAX=10; MAC_CFG_RX_MAX=10; HAL_UART=FALSE; HAL_DMA=TRUE; HAL_AES=FALSE; HAL_FLASH=TRUE; HAL_KEY=TRUE; HAL_ADC=TRUE; xNON_BANKED; WATCHDOG=TRUE
  ICC8051.CCIncludePath2: ..\src\; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\MCU\CC2530; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MT; ..\..\..\..\..\..\common; ..\..\..\..\..\..\common\1g; ..\..\..\..\..\..; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\LocSys\Card\; ..\..\..\driver\LocSys\Card\common; ..\..\..\driver\MobilePhone\lcd; ..\..\..\driver\MobilePhone\ioexpand
configuration Router (8051)
  as the first configuration, except:
  ICC8051.CCDefines: STATION_PROJECT; ASSERT_RESET; LOCSYS_NODEROLE_ROUTER; xSLEEPTIME_ACCOUNTING; POWER_SAVING; MAC_CFG_TX_DATA_MAX=6; MAC_CFG_TX_MAX=10; MAC_CFG_RX_MAX=10; HAL_UART=FALSE; HAL_DMA=TRUE; HAL_AES=FALSE; HAL_FLASH=TRUE; HAL_ADC=TRUE; HAL_SPI=FALSE; xNON_BANKED; WATCHDOG=TRUE
  ICC8051.CCIncludePath2: ..\src\; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\MCU\CC2530; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MT; ..\..\..\..\..\..\common; ..\..\..\..\..\..\common\1g; ..\..\..\..\..\..; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\LocSys\Router\; ..\..\..\driver\LocSys\Router\common; ..\..\..\driver\MobilePhone\lcd; ..\..\..\driver\MobilePhone\ioexpand
configuration Handheld (8051)
  as the first configuration, except:
  ICC8051.CCDefines: LOCSYS_NODEROLE_HANDHELD; xSLEEPTIME_ACCOUNTING; POWER_SAVING; MAC_CFG_TX_DATA_MAX=6; MAC_CFG_TX_MAX=10; MAC_CFG_RX_MAX=10; HAL_UART=FALSE; HAL_DMA=TRUE; HAL_AES=FALSE; HAL_FLASH=TRUE; HAL_KEY=TRUE; HAL_ADC=TRUE; xNON_BANKED; WATCHDOG=TRUE
  ICC8051.CCIncludePath2: as above
configuration Station-NoSpiDebug (8051)
  as the first configuration, except:
  ICC8051.CCDefines: LOCSYS_NODEROLE_STATION; xSLEEPTIME_ACCOUNTING; xPOWER_SAVING; MAC_CFG_TX_DATA_MAX=6; MAC_CFG_TX_MAX=10; MAC_CFG_RX_MAX=10; HAL_UART=FALSE; HAL_DMA=TRUE; HAL_AES=FALSE; HAL_FLASH=FALSE; xNON_BANKED; LOCSYS_NO_SPI_CMD; LOCSYS_NO_SPI; HAL_PA_LNA
  ICC8051.CCIncludePath2: ..\src\; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\MCU\CC2530; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MT; ..\..\..\..\..\..\common; ..\..\..\..\..\..\common\1g; ..\..\..\..\..\..; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\LocSys\Card; ..\..\..\driver\LocSys\Card\common; ..\..\..\driver\MobilePhone\lcd; ..\..\..\driver\MobilePhone\ioexpand
configuration Router-hwcard (8051)
  as the first configuration, except:
  ICC8051.CCDefines: xOSC32K_CRYSTAL_INSTALLED=FALSE; LOCSYS_NODEROLE_ROUTER; xSLEEPTIME_ACCOUNTING; POWER_SAVING; MAC_CFG_TX_DATA_MAX=6; MAC_CFG_TX_MAX=10; MAC_CFG_RX_MAX=10; HAL_UART=FALSE; HAL_DMA=TRUE; HAL_AES=FALSE; HAL_FLASH=FALSE; HAL_ADC=TRUE; HAL_HALL=FALSE; HAL_BEEPER=FALSE; xNON_BANKED; HAL_PA_LNA
  ICC8051.CCIncludePath2: as above
  group Application
    ../src/: LocSys.h LocSys_Card.c LocSys_Handheld.c LocSys_Main.c LocSys_Nwk.c LocSys_Nwk.h LocSys_Osal.c LocSys_Protocol.h LocSys_Router.c LocSys_Station.c LocSys_Util.c LocSys_Util.h
  group HAL/Card
    ../../../driver/LocSys/Card/: hal_adc.c hal_beeper.c hal_beeper.h hal_board_cfg.h hal_dma.c hal_dma.h hal_flash.c hal_hall.c hal_hall.h hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.h hal_mcu.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h hal_uart.c
    ../../../driver/LocSys/Card/common/: hal_assert.c hal_assert.h hal_drivers.c hal_drivers.h OnBoard.c OnBoard.h
  group HAL/Router
    ../../../driver/LocSys/Router/: hal_adc.c hal_board_cfg.h hal_dma.c hal_dma.h hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.h hal_mcu.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h hal_uart.c
    ../../../driver/LocSys/Router/common/: hal_assert.c hal_assert.h hal_drivers.c hal_drivers.h OnBoard.c OnBoard.h
  group HAL/Station
    ../../../driver/LocSys/Station/: hal_adc.c hal_board_cfg.h hal_dma.c hal_dma.h hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.h hal_mcu.h hal_sleep.c hal_spi.c hal_spi.h hal_startup.c hal_timer.c hal_types.h hal_uart.c
    ../../../driver/LocSys/Station/common/: hal_assert.c hal_assert.h hal_drivers.c hal_drivers.h OnBoard.c OnBoard.h
  group MAC/High Level
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/high_level/: mac_cfg.c mac_pib.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../third_party/TIMAC-CC2530-1.3.1/Projects/mac/libraries/cc2530/IAR/bin/Lib/: macLib_cc2530-Banked.lib macLib_cc2530.lib
  group MAC/Include
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h mac_tx.h
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h
  group OSAL
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Services
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/services/saddr/: saddr.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/services/saddr/: saddr.h
  group Util
    ../../../../../../common/: crc.c
    ../../../util/: delay.s51 MacUtil.c WatchDogUtil.c
    ../cfg/: ti_51ew_cc2530b.xcl
