# IAR project SensorReader.ewp, settings and files
configuration SensorReader_Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCDefines: RRN; xWATCHDOG=TRUE; HAL_AES=FALSE; HAL_SPI=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; INT_HEAP_LEN=2000; CFG_UART_TXCTRL; SR_BOARD
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\CC2430\util; ..\..\..\..\..\common; ..\..\..\..\..\common\1g; ..\SOURCE; ..\..\..\common; ..\..\..\tree; ..\..\..\..\CC2430\third_party\TIMAC\Components\hal\include; ..\..\..\..\CC2430\driver; ..\..\..\..\CC2430\driver\SensorBoard; ..\..\..\..\CC2430\third_party\TIMAC\Components\OSAL\MCU\CCSOC; ..\..\..\..\CC2430\third_party\TIMAC\Components\OSAL\INCLUDE; ..\..\..\..\CC2430\third_party\TIMAC\Projects\mac\common\cc2430; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\NWK; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\SEC; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\SYS; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\ZDO; ..\..\..\..\CC2430\third_party\Zstack\COMPONENTS\ZMAC\F8W; ..\..\..\..\CC2430\third_party\TIMAC\Components\ZMAC; ..\..\..\..\CC2430\third_party\TIMAC\Components\SERVICES\SADDR; ..\..\..\..\CC2430\third_party\TIMAC\Components\SERVICES\SDATA; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\INCLUDE; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\HIGH_LEVEL; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\LOW_LEVEL\SRF03; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: ..\config\f8w2430.xcl
configuration SensorReader_Release (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: RRN; WATCHDOG=TRUE; HAL_AES=FALSE; HAL_SPI=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; INT_HEAP_LEN=2000; CFG_UART_TXCTRL; SR_BOARD
  group App
    ../../../../../common/1g/: MIC2000_CRC.c
    ../Source/: SensorReader.c SensorReader.h SR_Main.c SR_Osal.c
  group App/util
    ../../../util/: AppProtocolWrapper.c delay.s51 TimeUtil.c WatchDogUtil.c
    ../../../../../common/: crc.c
  group HAL/Common
    ../../../driver/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../driver/: hal_adc.h hal_defs.h hal_dma.h hal_key.h hal_key_cfg.h hal_lcd.h hal_led.h hal_mcu.h hal_sleep.h hal_spi.h hal_target.h hal_timer.h hal_uart.h
  group HAL/Target/SensorBoard/Config
    ../../../driver/SensorBoard/: hal_board.h hal_board_cfg.h
  group HAL/Target/SensorBoard/Drivers
    ../../../driver/SensorBoard/: hal_adc.c hal_dma.c hal_led.c hal_timer.c hal_uart.c
  group HAL/Target/SensorBoard/Includes
    ../../../driver/SensorBoard/: hal_aes.h hal_assert.h hal_ccm.h hal_drivers.h hal_mac_cfg.h hal_mailbox.h hal_SR_board_cfg.h hal_types.h
  group MAC/High Level
    ../../../third_party/TIMAC/Components/mac/high_level/: mac_cfg.c
  group MAC/Include
    ../../../third_party/TIMAC/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/: mac_autopend.c mac_backoff_timer.c mac_low_level.c mac_radio.c mac_rx.c mac_rx_onoff.c mac_sleep.c mac_tx.c
  group MAC/Low Level/System
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c
  group Services
    ../../../third_party/TIMAC/Components/services/saddr/: saddr.c
  group Services/OSAL
    ../../../third_party/TIMAC/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services/OSAL_NV
    ../../../third_party/TIMAC/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
  group Tools
    ../config/: f8w2430.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZMain
    ../../../third_party/Zstack/Projects/zstack/ZMain/TI2430DB/: chipcon_banked_code_support.s51 chipcon_cexit.s51 chipcon_cstartup.s51
