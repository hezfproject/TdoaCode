<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GasMonitor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>GasMonitor</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>wxlEndDevice</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>wxlRouter</configuration>
      </member>
      <member>
        <project>GasMonitor</project>
        <configuration>wxlCoordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


