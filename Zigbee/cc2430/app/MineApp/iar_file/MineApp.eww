<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MineApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>MineApp</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>wxlEndDevice</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>wxlRouter</configuration>
      </member>
      <member>
        <project>MineApp</project>
        <configuration>wxlCoordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


