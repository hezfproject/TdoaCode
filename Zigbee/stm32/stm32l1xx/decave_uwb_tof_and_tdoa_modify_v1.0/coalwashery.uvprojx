# Keil uVision project coalwashery.uvprojx, settings and files
target LPBSSv2.0 (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: coalwashery +hex
  AfterMake: fromelf --bin !L --output LPBSS_CARDv2.bin
  c flags: Optim=1 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD,FAKE_CALIBRATION,USE_SINGLE_RANGE,
  c misc: --c99
  c include: .\Application;.\Drivers;..\STM32L1xx_StdPeriph_Lib\CMSIS\Include;..\STM32L1xx_StdPeriph_Lib\CMSIS\Device\ST\STM32L1xx\Include;..\STM32L1xx_StdPeriph_Lib\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\common\ground\ground_v2;..\..\..\..;.\compiler;..\Common;..\Drivers;.\decadriver;..\..\..\..\common;..\..\..\..\common\2g
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./Application/: application.c mac_msg.c main.c mem.c timer_event.c debug.c instance.c deca_spi.c port.c unistd.c as3933.c channel.c instanceTdoa.c dotie.c
  group Startup
    ../STM32L1xx_StdPeriph_Lib/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
  group Drivers
    ../Drivers/: adc.c antenna.c beeper.c board.c button.c chipdev.c com_config.c led.c mcu.c motor.c spi_nano.c mma8452q.c hal_io_i2c.c sleep.c
  group STM32L1xx_StdPeriph_Lib
    ../STM32L1xx_StdPeriph_Lib/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    ../STM32L1xx_StdPeriph_Lib/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group decadriver
    ./decadriver/: deca_range_tables.c deca_device.c deca_params_init.c
  group Common
    ../Common/: printf_util.c
    ../../../../common/: crc.c
