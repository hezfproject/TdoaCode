<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SensorReader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SensorReader</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>wxlEndDevice</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>wxlRouter</configuration>
      </member>
      <member>
        <project>SensorReader</project>
        <configuration>wxlCoordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


