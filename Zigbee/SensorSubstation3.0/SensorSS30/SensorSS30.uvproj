# Keil uVision project SensorSS30.uvproj, settings and files
target SensorSS3.0 (MCS-51)
  device: C8051F350 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(50000000)
  output: SensorSS30 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source
    ./src/: main.c uart0.c adc0.c pca0.c io.c spi_slave.c timer0.c STARTUP.A51
  group Includes
    ./inc/: adc0.h c51f350.h io.h pca0.h spi_slave.h timer0.h type.h uart0.h
