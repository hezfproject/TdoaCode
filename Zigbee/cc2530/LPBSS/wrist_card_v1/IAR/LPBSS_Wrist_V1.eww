<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPBSS_Wrist_V1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


