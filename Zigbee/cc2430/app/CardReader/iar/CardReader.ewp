# IAR project CardReader.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430.i51
  ICC8051.CCDefines: RRN; WATCHDOG=TRUE; HAL_AES=FALSE; HAL_SPI=FALSE; HAL_UART=TRUE; HAL_KEY=FALSE; INT_HEAP_LEN=2000; CFG_UART_TXCTRL; CR_BOARD
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\CC2430\util; ..\..\..\..\..\common; ..\..\..\..\..; ..\..\..\..\..\common\1g; ..\SOURCE; ..\..\..\common; ..\..\..\tree; ..\..\..\..\CC2430\third_party\TIMAC\Components\hal\include; ..\..\..\..\CC2430\driver; ..\..\..\..\CC2430\driver\RRN; ..\..\..\..\CC2430\third_party\TIMAC\Components\OSAL\MCU\CCSOC; ..\..\..\..\CC2430\third_party\TIMAC\Components\OSAL\INCLUDE; ..\..\..\..\CC2430\third_party\TIMAC\Projects\mac\common\cc2430; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\NWK; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\SEC; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\SYS; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\ZDO; ..\..\..\..\CC2430\third_party\Zstack\COMPONENTS\ZMAC\F8W; ..\..\..\..\CC2430\third_party\TIMAC\Components\ZMAC; ..\..\..\..\CC2430\third_party\TIMAC\Components\SERVICES\SADDR; ..\..\..\..\CC2430\third_party\TIMAC\Components\SERVICES\SDATA; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\INCLUDE; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\HIGH_LEVEL; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\LOW_LEVEL\SRF03; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\cfg\f8w2430b.xcl
  group Application
    ../src/: CardReader.c CardReader.h CR_Main.c CR_Osal.c
    ../../../../../common/: crc.c
  group HAL
    ../../../driver/RRN/comm/: delay.s51
    ../../../driver/RRN/: hal_adc.c hal_dma.c hal_led.c hal_timer.c hal_uart.c
    ../../../driver/common/: hal_assert.c hal_drivers.c
  group MAC
    ../../../third_party/TIMAC/Projects/mac/libraries/cc2430/IAR/bin/Lib/: macLib_cc2430-Banked.lib
  group MAC/high_level
    ../../../third_party/TIMAC/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_main.h mac_pib.h mac_spec.h
  group MAC/low_level
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    ../../../third_party/TIMAC/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../cfg/: f8w2430b.xcl
    ../../../third_party/TIMAC/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../third_party/TIMAC/Components/services/saddr/: saddr.c
  group Util
    ../../../util/: FlashUtil.c MacUtil.c SleepUtil.c StringUtil.c TimeUtil.c WatchDogUtil.c
