# IAR project handset_station.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: STATION_PROJECT; ASSERT_RESET; ZTOOL_P2; WATCHDOG=TRUE; POOLSIZE=5; xTX_NEXT_CHECK; MAC_CFG_TX_DATA_MAX=9; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=10
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\; ..\src\MenuLib; ..\src\MenuLib\util; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MAC\LOW_LEVEL\SRF04\SINGLE_CHIP; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\OSAL\MCU\CC2530; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\TIMAC-CC2530-1.3.1\COMPONENTS\MT; ..\..\..\..\..\..\common\handset_station; ..\..\..\..\..\..\common\LPBSS; ..\..\..\..\..\..\..\common\ground; ..\..\..\..\..\..\..; ..\..\..\..\..\..\..\common; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\handset_station; ..\..\..\driver\handset_station\common
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\cfg\ti_51ew_cc2530b.xcl
  group Application
    ../src/: Station.c Station.h Station_Main.c Station_Osal.c
  group HAL/Common
    ../../../driver/include/: hal_sleep.h
  group HAL/Drivers
    ../../../driver/handset_station/: hal_flash.c
    ../../../driver/include/: hal_key.h hal_led.h hal_uart.h
  group HAL/Target/CC2530MP/Config
    ../../../driver/handset_station/: hal_board_cfg.h
  group HAL/Target/CC2530MP/Drivers
    ../../../driver/handset_station/common/: hal_assert.c hal_assert.h hal_drivers.c hal_drivers.h OnBoard.c OnBoard.h
    ../../../driver/handset_station/: hal_dma.c hal_dma.h hal_key.c hal_led.c hal_sleep.c hal_startup.c hal_uart.c
  group HAL/Target/CC2530MP/Includes
    ../../../driver/handset_station/: hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/high_level/: mac_cfg.c mac_pib.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../third_party/TIMAC-CC2530-1.3.1/Projects/mac/libraries/cc2530/IAR/bin/Lib/: macLib_cc2530-Banked.lib macLib_cc2530.lib
  group MAC/Include
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h mac_tx.h
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h
  group OSAL
    ../../../driver/handset_station/: hal_timer.c
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/osal/mcu/cc2530/: OSAL_Nv.c
    ../cfg/: ti_51ew_cc2530b.xcl
  group Services
    ../../../third_party/TIMAC-CC2530-1.3.1/Components/services/saddr/: saddr.c
    ../../../third_party/TIMAC-CC2530-1.3.1/COMPONENTS/services/saddr/: saddr.h
  group Util
    ../../../../../../../common/: crc.c
    ../../../util/: MacUtil.c WatchDogUtil.c
