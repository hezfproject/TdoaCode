<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GasMonitorLocate.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>wxlEndDevice</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>wxlRouter</configuration>
      </member>
      <member>
        <project>GasMonitorLocate</project>
        <configuration>wxlCoordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


