# Keil uVision project template.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output 3g_station.bin
  c flags: Optim=3
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
