<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LF_station.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LF_station</project>
        <configuration>CC2530EB Object</configuration>
      </member>
      <member>
        <project>LF_station</project>
        <configuration>CC2530EB Object - Banked</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


