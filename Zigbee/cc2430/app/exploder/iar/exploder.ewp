# IAR project exploder.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430.i51
  ICC8051.CCDefines: CC2430DB; NOWARNING; WATCHDOG; HAL_DMA=FALSE; HAL_AES=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\; ..\..\..\third_party\TIMAC\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\TIMAC\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\third_party\TIMAC\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\TIMAC\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\; ..\..\..\..\..\common; ..\..\..\..\..\common\1g; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\exploder
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\cfg\f8w2430b.xcl
  group (top)
    ../cfg/: f8w2430b.xcl
  group Application
    ../src/: med.c med.h med_Main.c med_Osal.c
  group HAL
    ../../../driver/exploder/: hal_adc.c hal_assert.c hal_board_cfg.h hal_drivers.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.h hal_mcu.h hal_sleep.c hal_timer.c hal_types.h hal_uart.c OnBoard.c OnBoard.h
  group Lib
    ../../../third_party/TIMAC/Projects/mac/libraries/cc2430/IAR/bin/Lib/: macLib_cc2430-Banked.lib
  group MAC/High Level
    ../../../third_party/TIMAC/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_main.h mac_spec.h
    ../../../third_party/TIMAC/COMPONENTS/mac/HIGH_LEVEL/: mac_pib.h
  group MAC/Include
    ../../../third_party/TIMAC/COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c
    ../../../third_party/TIMAC/COMPONENTS/mac/LOW_LEVEL/srf03/: mac_rx.h mac_tx.h
  group MAC/Low Level/System
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c
    ../../../third_party/TIMAC/COMPONENTS/mac/LOW_LEVEL/srf03/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h mac_radio_defs.h
  group OSAL
    ../../../third_party/TIMAC/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c OSAL_Nv.h
    ../../../third_party/TIMAC/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../third_party/TIMAC/Components/services/saddr/: saddr.c
  group Util
    ../../../../../common/: crc.c
    ../../../util/: MacUtil.c WatchDogUtil.c
