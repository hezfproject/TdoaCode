# Keil uVision project C51NtrxDrv.uvproj, settings and files
target NtrxDrv (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(33000000) MODAT2
  output: C51NtrxDrv (library)
  AfterMake: cmd.exe /C copy .\out\C51NtrxDrv.Lib ..\C51NtrxDrv.Lib
  c flags: Optimize=8 SizeSpeed=1
  c include: ./inc/;../
  group Source
    ./src/: NtrxBBT.c NtrxChip.c NtrxGetCh.c NtrxGetPower.c NtrxGetRTC.c NtrxInit.c NtrxPara.c NtrxPowerDn.c NtrxPowerDnPad.c NtrxRange.c NtrxRegMap.c NtrxSetCh.c NtrxSetPower.c NtrxTask.c NtrxTrans.c NtrxGetRxMode.c NtrxSetAddr2.c NtrxSetRTC.c NtrxSetRxMode.c NtrxSetSyncWD.c
