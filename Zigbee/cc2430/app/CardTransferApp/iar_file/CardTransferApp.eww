<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CardTransferApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>CardTransferApp</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>wxlEndDevice</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>wxlRouter</configuration>
      </member>
      <member>
        <project>CardTransferApp</project>
        <configuration>wxlCoordinator</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


