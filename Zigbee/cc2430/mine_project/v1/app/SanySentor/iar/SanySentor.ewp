# IAR project SanySentor.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430.i51
  ICC8051.CCDefines: SANYSENTOR_PROJECT; ASSERT_RESET; xWATCHDOG=TRUE; POOLSIZE=5; TX_NEXT_CHECK; MAC_CFG_TX_DATA_MAX=9; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=10
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MT; ..\..\..\..\..\..\..\common; ..\..\..\..\..\..\..\common\1g; ..\..\..\..\..\..\..\common\mineapp; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\SanySentor; ..\..\..\driver\SanySentor\comm
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\cfg\f8w2430b.xcl
  group Application
    ../src/: transmitter.c transmitter.h transmitter_Main.c transmitter_Osal.c
  group HAL/Drivers
    ../../../driver/include/: hal_adc.h hal_key.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/SanySentor/Config
    ../../../driver/SanySentor/: hal_board_cfg.h
  group HAL/Target/SanySentor/Drivers
    ../../../driver/SanySentor/: hal_adc.c hal_dma.c hal_key.c hal_led.c hal_timer.c hal_uart.c
    ../../../driver/SanySentor/comm/: hal_assert.c hal_drivers.c
  group HAL/Target/SanySentor/Includes
    ../../../driver/SanySentor/: hal_board.h hal_mac_cfg.h hal_mailbox.h hal_types.h
  group MAC/High Level
    ../../../../../third_party/TIMAC/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../../../third_party/TIMAC/Projects/mac/libraries/cc2430/IAR/bin/Lib/: macLib_cc2430-Banked.lib macLib_cc2430.lib
  group MAC/Include
    ../../../../../third_party/TIMAC/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../third_party/TIMAC/Components/mac/low_level/srf03/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../third_party/TIMAC/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    ../../../../../third_party/TIMAC/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../cfg/: f8w2430b.xcl
    ../../../../../third_party/TIMAC/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../../../third_party/TIMAC/Components/services/saddr/: saddr.c
  group Util
    ../../../../../../../common/: crc.c
    ../../../util/: MacUtil.c StringUtil.c WatchDogUtil.c
