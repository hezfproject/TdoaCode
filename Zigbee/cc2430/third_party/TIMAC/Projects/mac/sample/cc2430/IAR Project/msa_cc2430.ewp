# IAR project msa_cc2430.ewp, settings and files
configuration CC2430DB Object (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430.i51
  ICC8051.CCDefines: CC2430DB; POWER_SAVING; HAL_DMA=FALSE; HAL_AES=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430DB; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\COMMON\CC2430\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\COMMON\CC2430\f8w2430.xcl
configuration CC2430EB Object (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; POWER_SAVING; HAL_DMA=FALSE; HAL_AES=FALSE
  ICC8051.CCIncludePath2: ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430EB; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\COMMON\CC2430\
configuration CC2430DB Object - Banked (8051, debug)
  as the first configuration, except:
  XLINK.XclFile: ..\..\..\COMMON\CC2430\f8w2430b.xcl
configuration CC2430EB Object - Banked (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; POWER_SAVING; HAL_DMA=FALSE; HAL_AES=FALSE
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\COMMON\CC2430\f8w2430b.xcl
  group Application
    ../../Application/: msa.c msa.h msa_Main.c msa_Osal.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
    ../../../../../Components/hal/include/: hal_assert.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    ../../../../../Components/hal/include/: hal_adc.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2430DB/Config
    ../../../../../Components/hal/target/CC2430DB/: hal_board_cfg.h
  group HAL/Target/CC2430DB/Drivers
    ../../../../../Components/hal/target/CC2430DB/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430DB/Includes
    ../../../../../Components/hal/target/CC2430DB/: hal_mcu.h hal_types.h
  group HAL/Target/CC2430EB/Config
    ../../../../../Components/hal/target/CC2430EB/: hal_board_cfg.h
  group HAL/Target/CC2430EB/Drivers
    ../../../../../Components/hal/target/CC2430EB/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430EB/Includes
    ../../../../../Components/hal/target/CC2430EB/: hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../Libraries/cc2430/IAR/bin/Lib/: macLib_cc2430-Banked.lib macLib_cc2430.lib
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf03/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../../../Components/services/saddr/: saddr.c
