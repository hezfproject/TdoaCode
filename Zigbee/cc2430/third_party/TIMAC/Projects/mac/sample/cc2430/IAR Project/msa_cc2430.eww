<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msa_cc2430.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>msa_cc2430</project>
        <configuration>CC2430DB Object</configuration>
      </member>
      <member>
        <project>msa_cc2430</project>
        <configuration>CC2430DB Object - Banked</configuration>
      </member>
      <member>
        <project>msa_cc2430</project>
        <configuration>CC2430EB Object</configuration>
      </member>
      <member>
        <project>msa_cc2430</project>
        <configuration>CC2430EB Object - Banked</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


