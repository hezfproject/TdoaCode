# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F207VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output 3g_station.bin
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\..\..;..\..\..\..\common;..\..\..\..\common\2g;..\..\rt-thread\components\dfs;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\init;..\..\rt-thread\components\net\lwip\src;..\..\rt-thread\components\net\lwip\src\arch\include;..\..\rt-thread\components\net\lwip\src\include;..\..\rt-thread\components\net\lwip\src\include\ipv4;..\..\rt-thread\components\net\lwip\src\include\netif;..\..\rt-thread\include;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m4;..\STM32F2xx_Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\STM32F2xx_Libraries\STM32F2xx_StdPeriph_Driver\inc;applications;drivers
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    applications/: 3g_log.c 3g_watchdog.c application.c bootcfg.c bsmac_parser.c led_indicator.c location_data.c mbus_app.c msg_center.c net_app.c open_transmit.c startup.c system_stm32f2xx.c upgrade_flag.c
  group Drivers
    drivers/: board.c platform.c usart.c ext_sram.c stm32f2xx_it.c stm32_flash.c stm32f2xx_eth.c stm32f20x_40x_spi.c spi_flash_w25qxx.c stm32f2_rtc.c
  group STM32_StdPeriph
    ../STM32F2xx_Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../STM32F2xx_Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group protocol
    ../../../../common/: crc.c
  group Kernel
    ../../rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/rtc/: rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group Components
    ../../rt-thread/components/init/: components.c
  group LwIP
    ../../rt-thread/components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../rt-thread/components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../rt-thread/components/net/lwip/src/netif/: etharp.c ethernetif.c slipif.c
