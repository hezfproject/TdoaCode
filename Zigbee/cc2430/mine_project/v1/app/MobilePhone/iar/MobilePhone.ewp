# IAR project MobilePhone.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430.i51
  ICC8051.CCDefines: xSMS_TEMPLATE; MENU_CLOCKFORMAT; CELLSWITCH_DEBUG; MP_INFORMATION; HOLD_AUTO_START; SMS_SENDBOX; NEW_MENU_LIB; WATCHDOG=TRUE; NEW_DOUBLE_NVID_OP; AUDIO_SERIAL; NWK_AUTO_POLL; OSC32K_CRYSTAL_INSTALLED=FALSE; xAUDIO_TEST; xSINGLE_AUDIO_TEST; xMULTIAUDIO_TEST; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_AUDIO=TRUE; HAL_SPI=FALSE; HAL_UART=FALSE; HAL_LED=FALSE; HAL_AES=FALSE; HAL_KEY=TRUE; IDX_THRESHOLD=12; xMACNODEBUG; xMAC_NO_PARAM_CHECK; HAL_AUDIO=TRUE; HAL_DMA=FALSE; HAL_AES=FALSE; MAC_CFG_TX_DATA_MAX=8; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=8
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\; ..\src\MenuLib; ..\src\MenuLib\util; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MT; ..\..\..\..\..\..\..\common; ..\..\..\..\..\..\..\common\1g; ..\..\..\..\..\..\..; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\MobilePhone; ..\..\..\driver\MobilePhone\audio; ..\..\..\driver\MobilePhone\common; ..\..\..\driver\MobilePhone\key; ..\..\..\driver\MobilePhone\lcd
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\cfg\f8w2430b.xcl
configuration Debug (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: MENU_RF_DEBUG; RSSI_INFORMATION; PACKAGE_INFORMATION; MENU_OAD_UPDATE; xSMS_TEMPLATE; MENU_CLOCKFORMAT; CELLSWITCH_DEBUG; MP_INFORMATION; HOLD_AUTO_START; SMS_SENDBOX; NEW_MENU_LIB; WATCHDOG=TRUE; NEW_DOUBLE_NVID_OP; AUDIO_SERIAL; NWK_AUTO_POLL; OSC32K_CRYSTAL_INSTALLED=FALSE; xAUDIO_TEST; xSINGLE_AUDIO_TEST; xMULTIAUDIO_TEST; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_AUDIO=TRUE; HAL_SPI=FALSE; HAL_UART=FALSE; HAL_LED=FALSE; HAL_AES=FALSE; HAL_KEY=TRUE; IDX_THRESHOLD=12; xMACNODEBUG; xMAC_NO_PARAM_CHECK; HAL_AUDIO=TRUE; HAL_DMA=FALSE; HAL_AES=FALSE; MAC_CFG_TX_DATA_MAX=8; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=8
  ICC8051.CCIncludePath2: ..\src\; ..\src\MenuLib; ..\src\MenuLib\util; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\third_party\TIMAC\COMPONENTS\MT; ..\..\..\..\..\..\..\common; ..\..\..\..\..\..\..\common\2g; ..\..\..\driver; ..\..\..\util; ..\..\..\driver\include; ..\..\..\driver\common; ..\..\..\driver\MobilePhone; ..\..\..\driver\MobilePhone\audio; ..\..\..\driver\MobilePhone\common; ..\..\..\driver\MobilePhone\key; ..\..\..\driver\MobilePhone\lcd
  group Application
    ../../../util/: MacUtil.c MacUtil.h
    ../src/: MobilePhone.c MobilePhone.h MobilePhone_Dep.c MobilePhone_Function.c MobilePhone_global.c MobilePhone_Main.c MobilePhone_MenuLib.c MobilePhone_Osal.c
  group Application/Menu
    ../src/MenuLib/: MenuLib_global.c MenuLib_Nv.c MenuLib_orphan.c MenuLib_tree.c
  group Application/Menu/util
    ../src/MenuLib/Util/: 51PY.c MenuAdjustUtil.c MenuChineseInputUtil.c TimeUtil.c
  group HAL/Drivers
    ../../../driver/include/: hal_adc.h hal_key.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2430MP/Config
    ../../../driver/MobilePhone/: hal_board_cfg.h
  group HAL/Target/CC2430MP/Drivers
    ../../../driver/MobilePhone/audio/: audio_ambe_serial.c codec_fm11ge300.c codec_i2c.c
    ../../../driver/MobilePhone/: hal_adc.c hal_alarm.c hal_audio.c hal_key.c hal_sleep.c hal_timer.c KeyAudioISR.c
    ../../../driver/MobilePhone/common/: hal_assert.c hal_drivers.c OnBoard.c
    ../../../driver/MobilePhone/key/: key.c
    ../../../driver/MobilePhone/lcd/: lcd_serial.c
  group HAL/Target/CC2430MP/Includes
    ../../../driver/MobilePhone/common/: hal_assert.h hal_drivers.h OnBoard.h
    ../../../driver/: hal_mcu.h hal_types.h
    ../../../driver/MobilePhone/: KeyAudioISR.h
  group MAC/High Level
    ../../../../../third_party/TIMAC/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../../../third_party/TIMAC/Projects/mac/libraries/cc2430/IAR/bin/Lib/: macLib_cc2430-Banked.lib macLib_cc2430.lib
  group MAC/Include
    ../../../../../third_party/TIMAC/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../third_party/TIMAC/Components/mac/low_level/srf03/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../third_party/TIMAC/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    ../../../../../third_party/TIMAC/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../cfg/: f8w2430b.xcl MobilePhone.cfg
    ../../../../../third_party/TIMAC/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../../../third_party/TIMAC/Components/services/saddr/: saddr.c
  group Util
    ../../../util/: delay.s51 SleepUtil.c StringUtil.c WatchDogUtil.c
    ../../../../../../../common/2g/: numtrans.c
    ../../../driver/MobilePhone/audio/: voicedqueue.c
