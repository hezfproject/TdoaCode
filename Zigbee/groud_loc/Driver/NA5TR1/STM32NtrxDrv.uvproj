# Keil uVision project STM32NtrxDrv.uvproj, settings and files
target LIB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32NtrxDrv +hex (library)
  AfterMake: cmd.exe /C copy .\Out\STM32NtrxDrv.Lib ..\STM32NtrxDrv.Lib
  c flags: wLevel=2
  c include: ./inc/;../
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./src/: NtrxBBT.c NtrxChip.c NtrxGetCh.c NtrxGetPower.c NtrxGetRTC.c NtrxGetRxMode.c NtrxInit.c NtrxWarmInit.c NtrxPara.c NtrxPowerDn.c NtrxPowerDnPad.c NtrxRange.c NtrxRegMap.c NtrxSetAddr2.c NtrxSetCh.c NtrxSetPower.c NtrxSetRTC.c NtrxSetRxMode.c NtrxSetSyncWD.c NtrxTask.c NtrxTrans.c
