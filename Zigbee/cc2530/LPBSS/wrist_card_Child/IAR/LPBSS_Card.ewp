# IAR project LPBSS_Card.ewp, settings and files
configuration WristCard (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: WRIST_CARD_PROJ; USE_HEAP; xUSE_BUZZER; x_DEBUG_TICK; OPEN_WTD; OPEN_SLEEP; PROTO_TYPE_ADAP; xUSE_CC2591
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../SUP; ../DEV; ../SDK; ../APP; ../../../../common/LPBSS; ../../../../../common/ground; ../../../../../
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: cfg\ti_51ew_cc2530b.xcl
  group (top)
    ../DEV/: hal_flash.h
  group APP
    ../APP/: app_card_wireless.c app_card_wireless.h app_flash.c app_flash.h wrist_card.c wrist_card.h
    ../../../../../common/: crc.c
  group BSP
    ../SDK/: bsp_led.c bsp_led.h
  group CFG
    cfg/: ti_51ew_cc2530b.xcl
  group DEV
    ../DEV/: hal_adc.c hal_adc.h hal_beeper.c hal_beeper.h hal_button.c hal_button.h hal_dma.c hal_dma.h hal_flash.c hal_io_iic.c hal_io_iic.h hal_lcd.c hal_lcd.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_sleep.c hal_sleep.h hal_startup.c hal_timer.c hal_timer.h mma8452q.c mma8452q.h ssd1306.c ssd1306.h
  group SDK
    ../SDK/: bsp.c bsp.h bsp_beep.c bsp_beep.h bsp_flash.c bsp_flash.h bsp_key.c bsp_key.h rf.c rf.h sms.c sms.h
  group SUP
    ../SUP/: defs.h mem.c timer_event.c types.h
