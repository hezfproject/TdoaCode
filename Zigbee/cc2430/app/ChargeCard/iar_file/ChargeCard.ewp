# IAR project ChargeCard.ewp, settings and files
configuration RRN (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\chipcon\CC2430.i51
  ICC8051.CCDefines: CHARGEED_PROJECT; POWER_SAVING; OSC32K_CRYSTAL_INSTALLED=FALSE; CFG_PRECISE_TIMER; MACNODEBUG; MAC_NO_PARAM_CHECK; xPM1_ONLY=TRUE; RRN; WATCHDOG; WATCHDOG_TEST; xDEBUG; xTIME_TEST; xED_TEST; xED_TEST_RECYCLE; CPU32MHZ; HAL_DMA=FALSE; HAL_AES=FALSE; HAL_LCD=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\..\..\util; ..\..\..\..\..\common; ..\..\..\..\..\common\1g; ..\SOURCE; ..\..\..\third_party\Zstack\Projects\zstack\ZMAIN\TI2430DB; ..\..\..\third_party\Zstack\COMPONENTS\MT; ..\..\..\third_party\Zstack\COMPONENTS\HAL\INCLUDE; ..\..\..\driver; ..\..\..\driver\RRN; ..\..\..\driver\RRN\comm; ..\..\..\driver\RRN\beeper; ..\..\..\third_party\Zstack\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\Zstack\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\third_party\Zstack\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\Zstack\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\Zstack\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\Zstack\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\Zstack\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\third_party\Zstack\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: ..\config\ChargeCard.xcl
  group (top)
    ../../../util/: AppProtocolWrapper.c
  group Application
    ../Source/: ChargeCard.c ChargeCard.h ChargeCard_Main.c ChargeCard_Osal.c
  group HAL/Common
    ../../../driver/yiri_MP/comm/: delay.h delay.s51
    ../../../driver/common/: hal_assert.c hal_drivers.c
  group HAL/Drivers
    ../../../driver/: hal_adc.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_mcu.h hal_sleep.h hal_target.h hal_timer.h
  group HAL/Target/BFN/Config
    ../../../driver/BFN/: hal_board_cfg.h hal_target.c
  group HAL/Target/BFN/Drivers
    ../../../driver/BFN/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c
  group HAL/Target/BFN/Includes
    ../../../driver/BFN/: hal_board.h hal_mac_cfg.h hal_types.h
  group HAL/Target/CC2430DB/Config
    ../../../driver/TestBoard/: hal_board_cfg.h hal_target.c
  group HAL/Target/CC2430DB/Drivers
    ../../../driver/TestBoard/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c
  group HAL/Target/CC2430DB/Includes
    ../../../driver/TestBoard/: hal_board.h hal_mac_cfg.h hal_types.h
  group HAL/Target/RRN/Config
    ../../../driver/RRN/: hal_board_cfg.h hal_target.c
  group HAL/Target/RRN/Drivers
    ../../../driver/RRN/beeper/: beeper.c
    ../../../driver/RRN/comm/: drivers.c
    ../../../driver/RRN/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c
  group HAL/Target/RRN/Includes
    ../../../driver/RRN/: hal_board.h hal_mac_cfg.h hal_types.h
  group MAC/High Level
    ../../../third_party/Zstack/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../third_party/Zstack/Projects/zstack/Libraries/TIMAC/bin/: macLib_cc2430.lib
  group MAC/Include
    ../../../third_party/Zstack/COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/Zstack/Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c
    ../../../third_party/Zstack/COMPONENTS/mac/LOW_LEVEL/srf03/: mac_rx.h mac_tx.h
  group MAC/Low Level/System
    ../../../third_party/Zstack/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    ../../../third_party/Zstack/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../../../third_party/Zstack/Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
    ../../../third_party/Zstack/COMPONENTS/osal/include/: ZComDef.h
  group Services
    ../../../third_party/Zstack/Components/services/saddr/: saddr.c
  group Tools
    ../config/: ChargeCard.xcl
  group Utils
    ../../../util/: FlashUtil.c MacUtil.c SleepUtil.c time.c WatchDogUtil.c
