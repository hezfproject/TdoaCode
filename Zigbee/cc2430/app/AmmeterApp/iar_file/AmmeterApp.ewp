# IAR project AmmeterApp.ewp, settings and files
configuration CollectorRRN (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCDefines: RRN; CFG_AMMETER_MODBUS; AMMETER_COLLECTOR; xHOLD_AUTO_START; WATCHDOG=TRUE; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_SPI=FALSE; HAL_UART=TRUE; xHAL_LED=FALSE; xMT_TASK; xDEBUG_AMMETER
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\..\..\util; ..\..\..\..\..\..\ALGORITHM\lib\LocationEngine; ..\..\..\..\..\common; ..\SOURCE; ..\SOURCE\Location; ..\..\..\third_party\Zstack\Projects\zstack\ZMAIN\TI2430DB; ..\..\..\third_party\Zstack\COMPONENTS\MT; ..\..\..\third_party\Zstack\COMPONENTS\HAL\INCLUDE; ..\..\..\driver; ..\..\..\driver\RRN; ..\..\..\third_party\Zstack\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\third_party\Zstack\COMPONENTS\OSAL\INCLUDE; ..\..\..\third_party\Zstack\COMPONENTS\STACK\AF; ..\..\..\third_party\Zstack\COMPONENTS\STACK\NWK; ..\..\..\third_party\Zstack\COMPONENTS\STACK\SEC; ..\..\..\third_party\Zstack\COMPONENTS\STACK\SYS; ..\..\..\third_party\Zstack\COMPONENTS\STACK\ZDO; ..\..\..\third_party\Zstack\COMPONENTS\ZMAC\F8W; ..\..\..\third_party\Zstack\COMPONENTS\ZMAC; ..\..\..\third_party\Zstack\COMPONENTS\SERVICES\SADDR; ..\..\..\third_party\Zstack\COMPONENTS\SERVICES\SDATA; ..\..\..\third_party\Zstack\COMPONENTS\MAC\INCLUDE; ..\..\..\third_party\Zstack\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\third_party\Zstack\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\third_party\Zstack\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: ..\config\f8w2430.xcl
configuration CenterRRN (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: RRN; CFG_AMMETER_MODBUS; AMMETER_DATACENTER; xHOLD_AUTO_START; xZC_REPORT_TO_ARM; WATCHDOG=TRUE; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; xHAL_LED=FALSE; HAL_SPI=TRUE; xMT_TASK; xDEBUG_ROUTE; POOLSIZE=5; xMAXNEIGHBOR=4
configuration CollectorRRN_DebugNW (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: RRN; AMMETER_COLLECTOR; xHOLD_AUTO_START; xWATCHDOG=TRUE; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_SPI=FALSE; HAL_UART=TRUE; xHAL_LED=FALSE; xMT_TASK; xDEBUG_AMMETER; DEBUG_REPORT_NW; CFG_AMMETER_CMDLINE; CFG_AMMETER_TRANSPARENT; AMMETER_APP_BAUD=HAL_UART_BR_115200
configuration CenterRRN_DebugNW (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: RRN; AMMETER_DATACENTER; xHOLD_AUTO_START; xZC_REPORT_TO_ARM; xWATCHDOG=TRUE; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; xHAL_LED=FALSE; HAL_SPI=FALSE; HAL_UART; xMT_TASK; xDEBUG_ROUTE; POOLSIZE=5; xMAXNEIGHBOR=4; DEBUG_REPORT_NW; CFG_AMMETER_CMDLINE; CFG_AMMETER_TRANSPARENT; AMMETER_APP_BAUD=HAL_UART_BR_115200
configuration CollectorRRN_IEC (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: RRN; CFG_AMMETER_IEC; AMMETER_COLLECTOR; xHOLD_AUTO_START; xWATCHDOG=TRUE; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; HAL_SPI=FALSE; HAL_UART=TRUE; xHAL_LED=FALSE; xMT_TASK; xDEBUG_AMMETER; AMMETER_APP_BAUD=HAL_UART_BR_300
configuration CenterRRN_IEC (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: RRN; CFG_AMMETER_IEC; AMMETER_DATACENTER; xHOLD_AUTO_START; xZC_REPORT_TO_ARM; xWATCHDOG=TRUE; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; xHAL_LED=FALSE; HAL_SPI=FALSE; HAL_UART=TRUE; xMT_TASK; xDEBUG_ROUTE; POOLSIZE=5; xMAXNEIGHBOR=4; AMMETER_APP_BAUD=HAL_UART_BR_300
  group App
    ../Source/: Ammeter_IEC.c AmmeterApp.c OSAL_AmmeterApp.c
  group App/util
    ../../../util/: App_cfg.h delay.s51 DQUE.c MacUtil.c SleepUtil.c StringUtil.c time.c TimeUtil.c WatchDogUtil.c
  group HAL/Common
    ../../../driver/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../driver/: hal_adc.h hal_defs.h hal_dma.h hal_key.h hal_key_cfg.h hal_lcd.h hal_led.h hal_mcu.h hal_sleep.h hal_spi.h hal_target.h hal_timer.h hal_uart.h
  group HAL/Target/Ammeter/Config
    ../../../driver/Ammeter/: hal_board_cfg.h hal_target.c
  group HAL/Target/Ammeter/Drivers
    ../../../driver/Ammeter/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_timer.c hal_uart.c
  group HAL/Target/Ammeter/Includes
    ../../../driver/Ammeter/: hal_board.h hal_mac_cfg.h hal_mailbox.h hal_types.h
  group HAL/Target/BFN/Config
    ../../../driver/BFN/: hal_board_cfg.h hal_target.c
  group HAL/Target/BFN/Drivers
    ../../../driver/BFN/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_timer.c hal_uart.c
  group HAL/Target/BFN/Includes
    ../../../driver/BFN/: hal_board.h hal_ccm.h hal_mac_cfg.h hal_mailbox.h hal_types.h
  group HAL/Target/CC2430DB/Config
    ../../../driver/TestBoard/: hal_board_cfg.h hal_target.c
  group HAL/Target/CC2430DB/Drivers
    ../../../driver/TestBoard/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430DB/Includes
    ../../../driver/TestBoard/: hal_board.h hal_mailbox.h hal_types.h
  group HAL/Target/RRN/Config
    ../../../driver/RRN/: hal_board_cfg.h hal_target.c
  group HAL/Target/RRN/Drivers
    ../../../driver/RRN/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_timer.c hal_uart.c
  group HAL/Target/RRN/Includes
    ../../../driver/RRN/: hal_board.h hal_mac_cfg.h hal_mailbox.h hal_types.h
  group HAL/Target/yiri_MP/Config
    ../../../driver/yiri_MP/: hal_board.h hal_target.c
  group HAL/Target/yiri_MP/Drivers
    ../../../driver/yiri_MP/comm/: delay.s51
    ../../../driver/yiri_MP/: hal_adc.c hal_audio.c hal_dma.c hal_key.c hal_led.c hal_sleep.c hal_spi.c hal_timer.c key_interface.c KeyAudioISR.c lcd_interface.c
  group HAL/Target/yiri_MP/Includes
    ../../../driver/yiri_MP/: hal_audio.h hal_board_cfg.h hal_mac_cfg.h hal_mailbox.h hal_types.h key_interface.h KeyAudioISR.h lcd_interface.h
  group MAC/High Level
    ../../../third_party/Zstack/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../third_party/Zstack/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../third_party/Zstack/Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../third_party/Zstack/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group MT
    ../../../third_party/Zstack/Components/mt/: DebugTrace.c DebugTrace.h MT_AF.c MT_AF.h MT_MAC.c MT_MAC.h MT_NWK.c MT_NWK.h MT_ZDO.c MT_ZDO.h MTEL.c SPIMgr.c SPIMgr.h
    ../../../third_party/Zstack/COMPONENTS/mt/: MTEL.h
  group NWK
    ../../../third_party/Zstack/Components/stack/nwk/: AddrMgr.h aps_frag.h aps_util.h nwk_globals.c nwk_util.h rtg.h
    ../../../third_party/Zstack/COMPONENTS/stack/nwk/: APS.h aps_groups.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.h reflecttrack.h
    ../../../third_party/Zstack/Components/stack/sys/: ZGlobals.c
    ../../../third_party/Zstack/COMPONENTS/stack/sys/: ZGlobals.h
  group Profile
    ../../../third_party/Zstack/Components/stack/af/: AF.c
    ../../../third_party/Zstack/COMPONENTS/stack/af/: AF.h
  group Security
    ../../../third_party/Zstack/COMPONENTS/stack/sec/: ssp.h
    ../../../third_party/Zstack/Components/stack/sec/: ssp_hash.h
  group Services
    ../../../third_party/Zstack/Components/services/saddr/: saddr.c
    ../../../third_party/Zstack/COMPONENTS/services/saddr/: saddr.h
  group Services/OSAL
    ../../../third_party/Zstack/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../../../third_party/Zstack/Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
    ../../../third_party/Zstack/COMPONENTS/osal/include/: OSAL.h OSAL_Custom.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../third_party/Zstack/COMPONENTS/osal/mcu/ccsoc/: OSAL_Nv.h
  group Tools
    ../config/: f8w2430.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../third_party/Zstack/Components/stack/zdo/: ZDApp.c ZDConfig.c ZDObject.c ZDProfile.c ZDSecMgr.c ZDSecMgr.h
    ../../../third_party/Zstack/COMPONENTS/stack/zdo/: ZDApp.h ZDConfig.h ZDObject.h ZDProfile.h
  group ZMac
    ../../../third_party/Zstack/Components/zmac/f8w/: zmac.c zmac_cb.c
    ../../../third_party/Zstack/COMPONENTS/zmac/: ZMAC.h
    ../../../third_party/Zstack/COMPONENTS/zmac/f8w/: zmac_internal.h
  group ZMain
    ../../../third_party/Zstack/Projects/zstack/ZMain/TI2430DB/: chipcon_banked_code_support.s51 chipcon_cexit.s51 chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
