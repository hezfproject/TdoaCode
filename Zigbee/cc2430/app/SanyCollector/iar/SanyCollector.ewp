# IAR project SanyCollector.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430.i51
  ICC8051.CCDefines: RRN; WATCHDOG=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\..\CC2430\util; ..\..\..\..\..\common; ..\..\..\..\..\common\1g; ..\..\..\..\..; ..\..\..\..\CC2430\driver; ..\..\..\..\CC2430\driver\SanyCollector; ..\..\..\..\CC2430\driver\SanyCollector\comm; ..\..\..\..\CC2430\third_party\TIMAC\Components\OSAL\MCU\CCSOC; ..\..\..\..\CC2430\third_party\TIMAC\Components\OSAL\INCLUDE; ..\..\..\..\CC2430\third_party\TIMAC\Projects\mac\common\cc2430; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\NWK; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\SEC; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\SYS; ..\..\..\..\CC2430\third_party\TIMAC\Components\STACK\ZDO; ..\..\..\..\CC2430\third_party\Zstack\COMPONENTS\ZMAC\F8W; ..\..\..\..\CC2430\third_party\TIMAC\Components\ZMAC; ..\..\..\..\CC2430\third_party\TIMAC\Components\SERVICES\SADDR; ..\..\..\..\CC2430\third_party\TIMAC\Components\SERVICES\SDATA; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\INCLUDE; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\HIGH_LEVEL; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\LOW_LEVEL\SRF03; ..\..\..\..\CC2430\third_party\TIMAC\Components\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\cfg\f8w2430b.xcl
  group Application
    ../src/: SanyCollector.c SanyCollector.h SanyCollector_Main.c SanyCollector_Osal.c
  group HAL
    ../../../driver/SanyCollector/: hal_adc.c hal_led.c hal_uart.c
    ../../../driver/SanyCollector/comm/: hal_assert.c hal_assert.h hal_drivers.c hal_drivers.h OnBoard.c OnBoard.h
  group MAC
    ../../../third_party/TIMAC/Projects/mac/libraries/cc2430/IAR/bin/Lib/: macLib_cc2430-Banked.lib macLib_cc2430.lib
  group MAC/high_level
    ../../../third_party/TIMAC/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_main.h mac_pib.h mac_spec.h
  group MAC/low_level
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
    ../../../third_party/TIMAC/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    ../../../third_party/TIMAC/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../cfg/: f8w2430b.xcl
    ../../../third_party/TIMAC/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Services
    ../../../third_party/TIMAC/Components/services/saddr/: saddr.c
  group Util
    ../../../../../common/: crc.c
    ../../../util/: delay.s51 MacUtil.c WatchDogUtil.c
