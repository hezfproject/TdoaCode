# IAR project GasMonitorLocate_V2.ewp, settings and files
configuration GasMonitorLocate_V2 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCDefines: WATCHDOG=TRUE; NONWK; OSC32K_CRYSTAL_INSTALLED=FALSE; HOLD_AUTO_START; USE_TIMER_3; GASMONITOR_PROJECT; xCFG_GAS_SHORTMESSAGE; CFG_GAS_INFORMATION; xCFG_GAS_CARDCHECK; MENU_CLOCKFORMAT; xMINE_PROJECTS; TX_NEXT_CHECK; xMINE_TEST; xREFLECTOR; xLCD_SUPPORTED; HAL_LCD=FALSE; xHAL_LED=FALSE; xMT_TASK; POOLSIZE=5; MAC_CFG_TX_DATA_MAX=9; MAC_CFG_TX_MAX=12; MAC_CFG_RX_MAX=10; MACNODEBUG; MAC_NO_PARAM_CHECK; INT_HEAP_LEN=3700; SMS_NVDEFRAG
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..\util; ..\..\..\..\..\..\common; ..\..\..\..\..\..\..\common; ..\..\..\..\..\..\..; ..\..\..\..\..\..\..\common\1g; ..\SOURCE; ..\SOURCE\MenuLib; ..\Source\MenuLib\Util; ..\..\..\..\..\third_party\Zstack\Projects\zstack\ZMAIN\TI2430DB; ..\..\..\..\..\third_party\Zstack\COMPONENTS\MT; ..\..\..\..\..\third_party\Zstack\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\driver; ..\..\..\driver\GasMonitorLocate_V2; ..\..\..\driver\GasMonitorLocate_V2\comm; ..\..\..\driver\GasMonitorLocate_V2\key; ..\..\..\driver\GasMonitorLocate_V2\lcd; ..\..\..\driver\GasMonitorLocate_V2\ch4; ..\..\..\driver\GasMonitorLocate_V2\beeper; ..\..\..\..\..\third_party\Zstack\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\third_party\Zstack\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\third_party\Zstack\COMPONENTS\STACK\AF; ..\..\..\..\..\third_party\Zstack\COMPONENTS\STACK\NWK; ..\..\..\..\..\third_party\Zstack\COMPONENTS\STACK\SEC; ..\..\..\..\..\third_party\Zstack\COMPONENTS\STACK\SYS; ..\..\..\..\..\third_party\Zstack\COMPONENTS\STACK\ZDO; ..\..\..\..\..\third_party\Zstack\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\third_party\Zstack\COMPONENTS\ZMAC; ..\..\..\..\..\third_party\Zstack\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\third_party\Zstack\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\third_party\Zstack\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\third_party\Zstack\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\third_party\Zstack\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\third_party\Zstack\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: ..\config\f8w2430.xcl
  group App
    ../Source/: GasMonitor.c GasMonitor_MenuLib.c GasMonitor_Osal.c GasMonitor_sms.c GasMonitorDep.c Locate_uart.c
  group App/MenuLib
    ../Source/MenuLib/: GasMenuLib_global.c GasMenuLib_orphan.c GasMenuLib_tree.c
  group App/MenuLib/util
    ../Source/MenuLib/Util/: MenuAdjustUtil.c
  group App/Util
    ../../../util/: MacUtil.c SleepUtil.c WatchDogUtil.c WatchDogUtil.h
    ../../../../../util/: SleepUtil.c sleepUtil.h TimeUtil.c WatchDogUtil.c WatchDogUtil.h
  group HAL
    ../../../../../../../common/: crc.c crc.h
  group HAL/Common
    ../../../driver/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../driver/: hal_adc.h hal_defs.h hal_dma.h hal_key.h hal_key_cfg.h hal_lcd.h hal_led.h hal_mcu.h hal_sleep.h hal_spi.h hal_target.h hal_timer.h hal_uart.h
  group HAL/Target/GasMonitorLocate_V2/Config
    ../../../driver/GasMonitorLocate_V2/: hal_board_cfg.h
  group HAL/Target/GasMonitorLocate_V2/Drivers
    ../../../driver/GasMonitorLocate_V2/beeper/: beeper.c
    ../../../driver/GasMonitorLocate_V2/ch4/: ch4.c temperature.c
    ../../../driver/GasMonitorLocate_V2/comm/: delay.s51 drivers.c
    ../../../driver/GasMonitorLocate_V2/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_timer.c hal_uart.c KeyAudioISR.c lcd_interface.c
    ../../../driver/GasMonitorLocate_V2/key/: key.c
  group HAL/Target/GasMonitorLocate_V2/Includes
    ../../../driver/GasMonitorLocate_V2/key/: key.h
  group MAC/High Level
    ../../../../../third_party/Zstack/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../third_party/Zstack/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../third_party/Zstack/Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../third_party/Zstack/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group MT
    ../../../../../third_party/Zstack/Components/mt/: DebugTrace.c DebugTrace.h MT_AF.c MT_AF.h MT_MAC.c MT_MAC.h MT_NWK.c MT_NWK.h MT_ZDO.c MT_ZDO.h MTEL.c SPIMgr.c SPIMgr.h
    ../../../../../third_party/Zstack/COMPONENTS/mt/: MTEL.h
  group NWK
    ../../../../../third_party/Zstack/Components/stack/nwk/: AddrMgr.h aps_frag.h aps_util.h nwk_globals.c nwk_util.h rtg.h
    ../../../../../third_party/Zstack/COMPONENTS/stack/nwk/: APS.h aps_groups.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.h reflecttrack.h
    ../../../../../third_party/Zstack/Components/stack/sys/: ZGlobals.c
    ../../../../../third_party/Zstack/COMPONENTS/stack/sys/: ZGlobals.h
  group OSAL
    ../../../../../third_party/Zstack/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c
    ../../../../../third_party/Zstack/Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
    ../../../../../third_party/Zstack/COMPONENTS/osal/include/: OSAL.h OSAL_Custom.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../third_party/Zstack/COMPONENTS/osal/mcu/ccsoc/: OSAL_Nv.h
  group Profile
    ../../../../../third_party/Zstack/Components/stack/af/: AF.c
    ../../../../../third_party/Zstack/COMPONENTS/stack/af/: AF.h
  group Security
    ../../../../../third_party/Zstack/COMPONENTS/stack/sec/: ssp.h
    ../../../../../third_party/Zstack/Components/stack/sec/: ssp_hash.h
  group Services
    ../../../../../third_party/Zstack/Components/services/saddr/: saddr.c
    ../../../../../third_party/Zstack/COMPONENTS/services/saddr/: saddr.h
  group Tools
    ../config/: f8w2430.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../third_party/Zstack/Components/stack/zdo/: ZDApp.c ZDConfig.c ZDObject.c ZDProfile.c ZDSecMgr.c ZDSecMgr.h
    ../../../../../third_party/Zstack/COMPONENTS/stack/zdo/: ZDApp.h ZDConfig.h ZDObject.h ZDProfile.h
  group ZMac
    ../../../../../third_party/Zstack/Components/zmac/f8w/: zmac.c zmac_cb.c
    ../../../../../third_party/Zstack/COMPONENTS/zmac/: ZMAC.h
    ../../../../../third_party/Zstack/COMPONENTS/zmac/f8w/: zmac_internal.h
  group ZMain
    ../../../../../third_party/Zstack/Projects/zstack/ZMain/TI2430DB/: chipcon_banked_code_support.s51 chipcon_cexit.s51 chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
