# Keil uVision project Tag.uvproj, settings and files
target Tag (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Tag
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,NT_TAG,NT_DEMO_2,TAG_POWER_SAVING
  c include: ..\Tag;.\Board;..\..\Driver\NA5TR1\inc;..\..\Driver\OSAL\inc;..\..\Driver\STM32_CPU;..\..\Driver;..\..\STM32_Lib3.5\STM32F10x_StdPeriph_Driver\inc;..\..\STM32_Lib3.5\CMSIS\CM3\CoreSupport;..\..\STM32_Lib3.5\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../../STM32_Lib3.5/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group App
    ./: App.c Main.c Version.c
  group Driver
    ../../Driver/: HAL.c Utility.c sleep.c
    ../../Driver/Console/src/: ConPutDec.c ConPutHex.c ConPutNum.c ConPutRet.c ConPutSpc.c ConPutStr.c ConRdLine.c
    ../../Driver/NA5TR1/src/: NtrxBBT.c NtrxChip.c NtrxGetCh.c NtrxGetPower.c NtrxGetRTC.c NtrxGetRxMode.c NtrxInit.c NtrxPara.c NtrxPowerDn.c NtrxPowerDnPad.c NtrxRange.c NtrxRegMap.c NtrxSetAddr2.c NtrxSetCh.c NtrxSetPower.c NtrxSetRTC.c NtrxSetRxMode.c NtrxSetSyncWD.c NtrxTask.c NtrxTrans.c NtrxWarmInit.c
    ../../Driver/OSAL/src/: App_Osal.c OSAL.c OSAL_Clock.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../Driver/STM32_CPU/: _hal_uart_isr.c hal_uart.c STM32_CPU.c STM32_SPI.c STM32F103CB.c
  group Board
    ./Board/: KeyScan.c LED.c OLED.c
  group stm32_lib
    ../../STM32_Lib3.5/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../STM32_Lib3.5/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../STM32_Lib3.5/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
